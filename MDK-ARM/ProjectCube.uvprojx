# Keil uVision project ProjectCube.uvprojx, settings and files
target ProjectCube (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: ProjectCube +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;                                                         ../Drivers/STM32F7xx_HAL_Driver/Inc;                                                         ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                                                         ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                         ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                                         ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                                                         ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User
    ../Src/: fuzzy_F4.c NumType_F4.c FuzzyV1_F4.c MY_FLASH.c main.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f7xx_it.c stm32f7xx_hal_msp.c
    ../Inc/: fuzzy_enums.h fuzzy_F4.h main.h NumType_F4.h FuzzyV1_F4.h MY_FLASH.h
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
